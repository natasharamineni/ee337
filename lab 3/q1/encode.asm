ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE
ORG 130H

QUANT:
MOV R0, #60H
MOV R1, #70H
MOV R2, #8
LOOP: MOV A, @R0
CLR C
SUBB A, #1EH
JNC OP1
MOV A, @R0
CLR C
SUBB A, #14H
JNC OP2
MOV A, @R0
CLR C
SUBB A, #0AH
JNC OP3
MOV @R1, #05H
SJMP NEXT
OP3: MOV @R1, #0FH
SJMP NEXT
OP2: MOV @R1, #19H
SJMP NEXT
OP1: MOV @R1, #23H
NEXT: INC R0
INC R1
DJNZ R2, LOOP
RET
END