ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL FILT
HERE: SJMP HERE
ORG 130H

FILT:
MOV R0, #60H
MOV R1, #70H
MOV R3, #08H
NEXT: MOV A, R0
MOV R2, A
MOV A, @R0
MOV R4, #03H
LOOP: DEC R0
ADD A, @R0
DJNZ R4, LOOP
MOV B, #04H
DIV AB
MOV @R1, A
MOV A, R2
MOV R0, A
INC R0
INC R1
DJNZ R3, NEXT
RET
END