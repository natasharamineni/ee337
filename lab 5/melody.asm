ORG 0H
LJMP MAIN
ORG 100H
MAIN:
ACALL TAKEINP
HERE: SJMP HERE
ORG 130H
	
TAKEINP:
MOV P0, #0
MOV P1, #0FH
INF:
MOV A, P1
CJNE A, #01H, RE
JMP SA
RE:
MOV A, P1
CJNE A, #03H, GA
JMP RE1
GA:
MOV A, P1
CJNE A, #07H, MA
JMP GA1
MA:
MOV A, P1
CJNE A, #0FH, INF
JMP MA1

SA: CPL P0.7
ACALL DELAYSA
JMP INF

RE1:CPL P0.7
ACALL DELAYRE
JMP INF

GA1:CPL P0.7
ACALL DELAYGA
JMP INF

MA1:CPL P0.7
ACALL DELAYMA
JMP INF

ACALL TAKEINP
RET

DELAYSA:
PUSH 00H
MOV R2, #19
H4: ACALL delay_100us
DJNZ R2, H4
POP 00H
RET

DELAYRE:
PUSH 00H
MOV R2, #17
H5: ACALL delay_100us
DJNZ R2, H5
POP 00H
RET

DELAYGA:
PUSH 00H
MOV R2, #15
H6: ACALL delay_100us
DJNZ R2, H6
POP 00H
RET

DELAYMA:
PUSH 00H
MOV R2, #14
H3: ACALL delay_100us
DJNZ R2, H3
POP 00H
RET

delay_100us:
push 00h
mov r1, #94
h1: djnz r1, h1
pop 00h
ret

END


