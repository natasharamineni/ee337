ORG 0H
LJMP MAIN
ORG 100H
MAIN:
MOV R1, #61H
CALL MODADD
CALL MODSUB
HERE: SJMP HERE
ORG 130H

MODADD:
MOV A, 70H
MOV R2, 71H
MOV B, R1
ADD A, R2
DIV AB
MOV 72H, B
RET

MODSUB:
MOV A, 70H
MOV R2, 71H
MOV B, R1
CLR C
SUBB A, R2
JC HERE1
DIV AB
MOV R2, B
JNC HERE2
HERE1: MOV A, 71H
MOV R2, 70H
CLR C
SUBB A, R2
DIV AB
MOV R2, B
MOV A, R1
CLR C
SUBB A, R2
MOV R2, A
HERE2: MOV 73H, R2
RET 

END








